# Keil uVision project STC.uvproj, settings and files
target STC (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\USER;.\LIB\Data;.\LIB\eeprom;.\LIB\FunctionOS;.\LIB\OSAL;.\LIB\Scan;.\LIB\SEG;.\LIB\Tick;.\LIB\H;.\LIB\M_IO;.\LIB\M_Math;.\LIB\DATAST;.\LIB\IIC;.\USER\Mode;.\USER\Scankey;.\USER\Main;.\LIB\SYS
  group USER
    ./LIB/Data/: data.c
    ./LIB/FunctionOS/: functionOS.c
    ./USER/Mode/: Mode1.c
    ./USER/Scankey/: scankey.c
  group H-D
    ./LIB/Scan/: Scanf.c
    ./LIB/SEG/: SEG.c
    ./LIB/eeprom/: eeprom.c
  group OSST
    ./: STARTUP.A51
    ./LIB/OSAL/: OSAL.c
    ./USER/Main/: Main.c
  group SPFC
    ./LIB/Tick/: tickt.c
    ./LIB/M_IO/: MIO.c
